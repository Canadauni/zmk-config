## boards/shields/mini_pad_1/Kconfig.defconfig
```kconfig
if SHIELD_MINI_PAD_1

config ZMK_KEYBOARD_NAME
    default "mini_pad"

endif # SHIELD_MINI_PAD_1
```
